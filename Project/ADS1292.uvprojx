# Keil uVision project ADS1292.uvprojx, settings and files
target ADS1292 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ADS1292 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,ARM_MATH_CM3,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS\DeviceSupport\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\User;..\CMSIS\CoreSupport;..\CMSIS;..\User\Fonts;..\DSP_LIB;..\DSP_LIB\Include;..\APP\MLX90614;..\APP\System;..\APP\smbus;..\APP\SysTick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_it.c LED.c PeripheralInit.c Delay.c lze_lcd.c usart.c ADS1292.c spi.c EXTInterrupt.c
    ../APP/MLX90614/: mlx90614.c
    ../APP/System/: system.c
    ../APP/smbus/: smbus.c
    ../APP/SysTick/: SysTick.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/STM32F10x/: system_stm32f10x.c
  group Startup
    ../CMSIS/DeviceSupport/STM32F10x/: startup_stm32f10x_hd.s
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM3l_math.lib
software components: Data Exchange:JSON:Jansson 2.7.0
